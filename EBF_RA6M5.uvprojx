# Keil uVision project EBF_RA6M5.uvprojx, settings and files
target Target_1 (6100001::V6.10.1::.\ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: EBF_RA6M5 +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: ..\EBF_RA6M5;.\application;.\task;.\drivers;.\bsp;.\edge_ai;.\edge_ai\model;.\drivers\oled
  asm misc: --via=./via/rasc_armasm.via
  asm include: as above
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
  group Application
    ./application/: application_entry.c
  group Tasks
    ./task/: sensor_task.c display_task.c can_comm_task.c
  group Drivers
    ./drivers/: dht11.c us516p6.c light_sensor.c can_comm.c
    ./drivers/oled/: OLED.c
  group Board
    ./bsp/: soc_board.c
  group EdgeAI
    ./edge_ai/: edge_ai_app.c
    ./edge_ai/model/: drying_tree_model.c drying_ai_runtime.c
software components: Flex Software:RA Configuration 1.0.0
